# Keil uVision project Control Unit V1I0.uvprojx, settings and files
target Control Unit V1I0 (ARM-ADS)
  device: STM32F205VCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Control Unit V1I0
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CMSIS
    ./CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
    ./CMSIS/Device/ST/STM32F2xx/Include/: stm32f2xx.h stm32f205xx.h system_stm32f2xx.h
    ./CMSIS/Include/: core_cm3.h
  group Startup
    ./CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f205xx.s
